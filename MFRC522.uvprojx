# Keil uVision project MFRC522.uvprojx, settings and files
target MFRC522 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RC522 +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --C99
  c include: .\USER;.\CMSIS\CORE;.\CMSIS\STM32F10x_StdPeriph_Driver\inc;.\SYSTEM\sys;.\SYSTEM\delay;.\SYSTEM\usart;.\HARDWARE\LED;.\HARDWARE\SPI;.\HARDWARE\RC522;.\HARDWARE\MFRC522;.\HARDWARE\AX12
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c stm32f10x_conf.h
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/SPI/: spi.c
    ./HARDWARE/MFRC522/: mfrc522.c
  group SYSTEM
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/usart/: usart.c retarget.c
  group STM32_FWLib
    ./USER/: stm32f10x_it.c system_stm32f10x.c
    ./CMSIS/CORE/: core_cm3.c startup_stm32f10x_hd.s
    ./CMSIS/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
